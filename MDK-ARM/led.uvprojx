# Keil uVision project led.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: AIR001Dev Generic
  pack: Keil.AIR001_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: led +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: AIR001_DEV
  c include: ..\AIR001xx_HAL_Driver\Inc;..\User;..\Hardware\led
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group User
    ../User/: main.c air001xx_it.c
  group HAL
    ../AIR001xx_HAL_Driver/Src/: air001xx_hal.c air001xx_hal_rcc.c air001xx_hal_rcc_ex.c air001xx_hal_pwr.c air001xx_hal_pwr_ex.c air001xx_hal_cortex.c air001xx_hal_flash.c air001xx_hal_gpio.c
  group Hardware
    ../Hardware/led/: led.c
software components: CMSIS:CORE 5.6.0, Device:Startup 0.0.1
